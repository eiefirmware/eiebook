# IAR project eie_ascii-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EIE1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\..\firmware_common; ..\..\firmware_common\application; ..\..\firmware_common\bsp; ..\..\firmware_common\cmsis; ..\..\firmware_common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\bsp; ..\drivers; ..\application; ..\..\firmware_common; ..\..\firmware_common\application; ..\..\firmware_common\cmsis; ..\..\firmware_common\drivers
  OBJCOPY.OOCOutputFile: eiefw-01.hex
  ILINK.IlinkOutputFile: eie_ascii-01.out
  ILINK.IlinkIcfFile: $PROJ_DIR$l\..\..\firmware_common\bsp\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Includes
    ../../firmware_common/bsp/: AT91SAM3U4.h configuration.h sam3u2-flash.icf typedefs.h
    ../bsp/: eief1-pcb-01.h
  group _BSP/Source
    ../../firmware_common/bsp/: board_cstartup_iar.c kill_x_cycles.s
    ../bsp/: eief1-pcb-01.c
  group _CMSIS
    ../../firmware_common/cmsis/: core_cm3.h
  group _Drivers/Include
    ../../firmware_common/drivers/: buttons.h exceptions.h interrupts.h leds.h timer.h utilities.h
  group _Drivers/Source
    ../../firmware_common/drivers/: buttons.c exceptions.c interrupts.c leds.c timer.c utilities.c
  group Application/Include
    ../application/: main.h
    ../../firmware_common/application/: music.h user_app1.h user_app2.h user_app3.h
  group Application/Source
    ../application/: main.c
    ../../firmware_common/application/: user_app1.c user_app2.c user_app3.c
